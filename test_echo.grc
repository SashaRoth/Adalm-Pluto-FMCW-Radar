options:
  parameters:
    author: aroth
    generate_options: qt_gui
    id: test_echo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_start
  id: variable
  parameters:
    value: '1800000000'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '2000000000'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: dwell_time
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: light
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: n_steps
  id: variable
  parameters:
    value: int((stop_freq-start_freq) / step) + 1
  states: {}
- name: range_max
  id: variable
  parameters:
    value: '6'
  states: {}
- name: settle_time
  id: variable
  parameters:
    value: '0.0001'
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: '1800000000'
  states: {}
- name: step
  id: variable
  parameters:
    value: bandwidth/100
  states: {}
- name: stop_freq
  id: variable
  parameters:
    value: start_freq+bandwidth
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/dwell_time
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '10'
    samp_rate: tx_samp_rate
    sensitivity: bandwidth
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: tx_samp_rate
    type: ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: LO_start
    samplerate: tx_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LO_start
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: tx_samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: tx_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: tx_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vco_c_0, '0', iio_pluto_sink_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
